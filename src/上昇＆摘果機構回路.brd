# Repository ramunedesune/2023-

File README.md:

# 2023-robocon
２０２３年度のロボコンに向けた基板

## EAGLE design src/上昇＆摘果機構回路.brd

Parts:
0.1μ: GRM0335C1E240GA01D
AZUSA_CON1, AZUSA_CON2: 02-JST; B2B-XH
AZUSA_CTRL1: 02-JST; B2B-XH
BOOT: PINHD-1X2; 1X02
C1, C2, C3, C4: GRM0335C1E240GA01D
C5: GRM31CR71H475KA12
C11, C12: 10μ; GRM0335C1E240GA01D
C13, C14: 22μ; GRM0335C1E240GA01D
C15, C16, C17, C18, C19, C20, C21, C22, C24: GCM188L81H104KA57
C23: GRM21BC72A105KE01
CTRL: 02-JST; B2B-XH
DOWN: 02-JST; B2B-XH
ENC1, ENC2, ENC3: 05-JST; B5B-XH
FB1: BLM18KG121TN1D
H1, H2, H3, H4: MOUNT-HOLE3.2; 3,2
LEFT_D: PINHD-1X4; 1X04
LEFT_U: PINHD-1X2; 1X02
ML1, ML2: ML10
PIN_SOCKET1, PIN_SOCKET2: PINHD-1X2; 1X02
R1, R10, R11: 100; M0805
R2, R3: 0; M0805
R12: 150; M0805
REGYURETA: ３．３V; ＡＺ１１１７ＣＨ－３．３ＴＲＧ１
RIGHT_D: PINHD-1X4; 1X04
RIGHT_U: PINHD-1X2; 1X02
ST-LINK: PINHD-1X6; 1X06
T1: 2SC3325-Y,LF
TWE_LEFT: PINHD-1X14; 1X14
TWE_RIGHT: PINHD-1X14; 1X14
U$1: STM32F446RET6-LGRF64; STM32F446FRT6
U$2: TACTSWITCH
U$8: SMD1608チップLED
UP: 02-JST; B2B-XH
X1: 32.768K12.5PI/MC306
X2: RH100-24.000-18-1020-EXT-TR

Connections:
+3V3: BOOT.1, C13.1, C14.1, C19.P$1, C20.P$1, C21.P$1, C22.P$1, DOWN.2, FB1.1, ML1.2, REGYURETA.OUTPUT, REGYURETA.VOUT (OUTPUT), ST-LINK.1, TWE_RIGHT.1, U$1.VBAT, U$1.VDD1, U$1.VDD2, U$1.VDD3, U$1.VDD4, UP.2
+5V: C11.1, C12.1, C15.P$1, C16.P$1, C17.P$1, C18.P$1, ENC1.4, ENC2.4, ENC3.4, LEFT_D.4, ML2.2, REGYURETA.INPUT
BOOT0: BOOT.2, U$1.BOOT0
COM_LED: LEFT_D.3, U$1.PA4
COM_LED2: R12.1, TWE_RIGHT.14
CS: RIGHT_D.1, U$1.PB12
DIR1: ML1.9, U$1.PC5
DIR2: ML1.7, U$1.PC4
DIR3: ML1.5, U$1.PA7
DIR4: ML1.3, U$1.PA6
EN1_A: ENC1.3, U$1.PB2
EN1_B: ENC1.5, U$1.PB10
EN2_A: ENC2.3, U$1.PC6
EN2_B: ENC2.5, U$1.PC7
EN3_A: ENC3.3, U$1.PA8
EN3_B: ENC3.5, U$1.PA9
LED1: ML2.4, U$1.PC0
LED2: ML2.6, U$1.PB5
LED3: ML2.8, U$1.PB4
LED4: ML2.10, U$1.PA12
LED5: ML2.9, U$1.PA11
LED6: ML2.7, U$1.PA10
LED7: ML2.5, U$1.PC3
LED8: ML2.3, U$1.PC2
MISO: RIGHT_D.2, U$1.PB14
MOSI: RIGHT_D.3, U$1.PB15
unnamed: C2.2, R2.2, X1.4
unnamed: C5.1, U$1.VCAP_1
unnamed: C1.2, U$1.PC14-OSC32_IN, X1.1
unnamed: C3.2, U$1.PH0-OSC_IN, X2.1
unnamed: C4.2, R3.2, X2.3 (2)
unnamed: R3.1, U$1.PH1-OSC_OUT
unnamed: R2.1, U$1.PC15-OSC32_OUT
unnamed: CTRL.2, T1.EMITTER (E)
unnamed: AZUSA_CTRL1.2, R1.1, T1.COLLECTOR (C)
unnamed: R1.2, T1.BASE (B)
unnamed: R12.2, U$8.ANODE
unnamed: C23.P$1, C24.P$1, FB1.2, U$1.VDDA/VREF+
NO1: R10.1, U$1.PA3, UP.1
NO2: DOWN.1, R11.1, U$1.PA5
NRST: 0.1μ.1, ST-LINK.5, U$1.NRST, U$2.P$1
PGND: AZUSA_CTRL1.1, CTRL.1
PWM1: ML1.10, U$1.PC9
PWM1_SERVO: AZUSA_CON1.2, U$1.PB0
PWM2: ML1.8, U$1.PC8
PWM2_SERVO: AZUSA_CON2.2, U$1.PB6
PWM3: ML1.6, U$1.PA0
PWM4: ML1.4, U$1.PA1
RX: PIN_SOCKET1.2, TWE_LEFT.10
SCK: RIGHT_D.4, U$1.PB13
SGND: 0.1μ.2, AZUSA_CON1.1, AZUSA_CON2.1, C1.1, C2.1, C3.1, C4.1, C5.2, C11.2, C12.2, C13.2, C14.2, C15.P$2, C16.P$2, C17.P$2, C18.P$2, C19.P$2, C20.P$2, C21.P$2, C22.P$2, C23.P$2, C24.P$2, ENC1.1, ENC2.1, ENC3.1, LEFT_D.1, LEFT_U.1, LEFT_U.2, ML1.1, ML2.1, R10.2, R11.2, REGYURETA.ADJ/GND (GND), RIGHT_U.1, RIGHT_U.2, ST-LINK.3, TWE_LEFT.1, U$1.VSS1, U$1.VSS2, U$1.VSS3, U$1.VSS4, U$1.VSSA/VREF-, U$2.P$4, U$8.CATHODE, X2.2 (SHIELD), X2.4 (SHIELD)
SWCLK: ST-LINK.2, U$1.PA14
SWDIO: ST-LINK.4, U$1.PA13
SWO: ST-LINK.6, U$1.PB3
TX: PIN_SOCKET2.2, TWE_LEFT.3
UART_RX: PIN_SOCKET1.1, U$1.PC11
UART_TX: PIN_SOCKET2.1, U$1.PC10

Notes on the sheet:
TACT_switch
MCU
BOOTMODE
ST-link
CTRL_conversion
Moter_MIL_con
encorder
リセットスイッチ
Azusa＿boardのCTRLをBseries_boardのCTRL対応に変換する
series_regulater
Azusa基板（main基板）とcan通信して得た5Vを変圧して3V3を出力する
drill
CAN_BUS
Azusa基板はICも含まれた基板であるためメイン基板とし、 can通信で上昇＆摘果機構のIC（F446RE）と通信して５Vを得て、 ３V３として回路を駆動させる。
サブ基板としての役割）
Comfirmation LED
子機twelite
(ひにゃたHub)
Remote emergency switch のための通信
limit switch
Bypass Capacitor
A or B相とGNDの間にチャタリングノイズ対策にコンデンサを入れた方が良き？
シュミットトリガの回路とか...
ICへののノイズ流入 and 流出を防止
ユニバーサル基板で一応確認済み
DC電源ラインのノイズ対策インダクタンス
servo_PWMsupply_con

Board: 2 copper layers, 97.6 x 76.1 mm, 59 parts (11 on the bottom side), 57 nets.

## EAGLE design src/Mix necessary function.brd

Parts:
AZUSA: 02-JST; B2B-XH
AZUSA_CON1, AZUSA_CON2: 02-JST; B2B-XH
C1, C4: 0.33μF; GRM0335C1E240GA01D
C2, C3, C5, C6: 0.1μF; GRM0335C1E240GA01D
C7: GCM188L81H104KA57
D1: GS2M-LTP
H1, H2, H3, H4: MOUNT-HOLE3.2; 3,2
LED: 04-JST; B4B-XH
LED_SW: SS-12SDP2
LIPO＿THRU: XT90PW-M
Q1: SQJA16EP-T1_GE3
R1: 100; CR0603
R2: 820; CR0603
R3: 10; CR0603
R4: 10k; CR0603
SERVO1, SERVO2: 03-JST; B3B-XH
SW1, SW2: 02-JST; B2B-XH
THRU: 02-JST; B2B-XH
TLP1: TLP152
U$1: ＮＪＭ７８０６ＦＡ-6V
U$17: NJM7800SDL1-12V
ZD1: MMBZ5248B-TP

Connections:
+6V: C2.1, C3.1, SERVO1.2, SERVO2.2, U$1.OUTPUT
+12V: C5.1, C6.1, LED.4, U$17.VOUT (OUTPUT)
AGND: AZUSA.1, SW2.1
BLUE: LED.1, LED_SW.L
EM: SW1.1, SW2.2
GND: AZUSA_CON1.1, AZUSA_CON2.1, C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.P$2, LED_SW.C, LIPO＿THRU.-, SERVO1.1, SERVO2.1, TLP1.GND, U$1.GND, U$17.GND
unnamed: THRU.1, TLP1.CATHODE
unnamed: D1.C, R2.LEFT, TLP1.VO (VOUT)
unnamed: Q1.G, R2.RIGHT, R3.RIGHT, R4.RIGHT, ZD1.CATHODE (C)
unnamed: D1.A, R3.LEFT
unnamed: C7.P$1, LIPO＿THRU.+, Q1.D, TLP1.VCC
unnamed: R1.LEFT, THRU.2
unnamed: R1.RIGHT, TLP1.ANODE
PVCC: C1.1, C4.1, Q1.S1 (S), Q1.S2 (S), Q1.S3 (S), R4.LEFT, U$1.INPUT, U$17.VIN (INPUT), ZD1.ANODE (A)
PWM1_SERVO: AZUSA_CON1.2, SERVO1.3
PWM2_SERVO: AZUSA_CON2.2, SERVO2.3
RED: LED.2, LED_SW.R
VCC: AZUSA.2, SW1.2

Notes on the sheet:
And-circuit
LEDsupply
series_regulater
PVCC:22.2V
Servo_con
LIpo_supply
GCJ188R71H104KA12D
GRT188C8YA105KE13D
機能： ・サーボモータ用三芯コネクタ ・テープLED用の四芯コネクタ ・非常停止スイッチ用のAnｄ回路
servo(DS3235sg)： voltage 4.8-6.4V current about0.3A regulater 22.2Vから6Vに変圧 allowable loss(許容損失) 16W (22.2-6)*0.3=4.86W no problem
drill
逆方向漏れ防止
servoの非常停止機能の接続用コネクタ

Board: 2 copper layers, 53.0 x 58.0 mm, 32 parts (0 on the bottom side), 18 nets.

## EAGLE design src/remote emergency switch.brd

Parts:
C1, C2: 10μ; GRM0335C1E240GA01D
C3, C4: 22μ; GRM0335C1E240GA01D
C15: 0.1μ; C025-024X044
CELL_SUPPLY: 02-JST; B2B-XH
DEVICE: ＵＳＢコネクタ・ミニＢ(メス)
EME1: 02-JST; B2B-XH
H1, H2, H3: MOUNT-HOLE3.2; 3,2
REGYURETA: ３．３V; ＡＺ１１１７ＣＨ－３．３ＴＲＧ１
TWE_LEFT1, TWE_LEFT2: PINHD-1X14; 1X14
TWE_RIGHT1, TWE_RIGHT2: PINHD-1X14; 1X14

Connections:
+3V3: C3.1, C4.1, C15.1, CELL_SUPPLY.2, REGYURETA.OUTPUT, REGYURETA.VOUT (OUTPUT), TWE_RIGHT1.1, TWE_RIGHT2.1
+5V: C1.1, C2.1, DEVICE.VBUS (1), REGYURETA.INPUT
D+: DEVICE.D+ (3)
D-: DEVICE.D- (2)
EM1: EME1.2, TWE_RIGHT1.14
SGND: C1.2, C2.2, C3.2, C4.2, C15.2, CELL_SUPPLY.1, DEVICE.GND (5), EME1.1, REGYURETA.ADJ/GND (GND), TWE_LEFT1.1, TWE_LEFT2.1

Notes on the sheet:
中継twelite
dry cell supply
Emergency switch
親機twelite
series_regulater
supply
センサー固有パラメーター設定を０にするとtwelite内部でプルアップする
ミシン目（スリット）等の加工を加え、PCB製造後に切り離す
drill

Board: 2 copper layers, 47.9 x 49.5 mm, 16 parts (0 on the bottom side), 4 nets.

## Commit log

2023-09-11 2st commit
2023-09-12 1st fix
2023-09-12 3rd fix
2023-09-12 DRC fix
2023-09-13 twelite
2023-09-13 fix around twelite
2023-09-14 servo
2023-09-14 テープLED
2023-09-14 add serbo pin
2023-09-14 fix necefun
2023-09-14 silk update
2023-09-15 servo2
2023-09-15 servo3
2023-09-15 necefunc fix
2023-09-15 kicad necefunc
2023-09-15 fix twelite
2023-09-17 fix twelite circuit slot
2023-09-17 add servo emergency
